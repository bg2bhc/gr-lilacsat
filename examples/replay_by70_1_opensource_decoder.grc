<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>replay_by70_1_opensource_decoder</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>BY70-1 telemetry replay using opensource image decoder</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Replay BY70-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>digigain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>variable_constellation_0</value></param>
<param><key>const_points</key><value>[-1, 1]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/daniel/Descargas/record_by70-1_image.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>9600</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>csp_print_header</key>
<param><key>id</key><value>csp_print_header_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>csp_swap_header</key>
<param><key>id</key><value>csp_swap_header_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>lilacsat_fec_decode_b</key>
<param><key>id</key><value>lilacsat_fec_decode_b_0_0</value></param>
<param><key>frame_len</key><value>114</value></param>
<param><key>pass_all</key><value>False</value></param>
<param><key>using_convolutional_code</key><value>False</value></param>
<param><key>using_m</key><value>True</value></param>
</block>
<block>
<key>lilacsat_fec_decode_b</key>
<param><key>id</key><value>lilacsat_fec_decode_b_0_0_0</value></param>
<param><key>frame_len</key><value>114</value></param>
<param><key>pass_all</key><value>False</value></param>
<param><key>using_convolutional_code</key><value>False</value></param>
<param><key>using_m</key><value>True</value></param>
</block>
<block>
<key>lilacsat_image_decoder</key>
<param><key>id</key><value>lilacsat_image_decoder_0</value></param>
<param><key>display</key><value>True</value></param>
<param><key>path</key><value>/tmp</value></param>
</block>
<block>
<key>lilacsat_kiss_decode_pdu</key>
<param><key>id</key><value>lilacsat_kiss_decode_pdu_0</value></param>
</block>
<block>
<key>lilacsat_telemetry_parser</key>
<param><key>id</key><value>lilacsat_telemetry_parser_0</value></param>
</block>
<block>
<key>lilacsat_vitfilt27_fb</key>
<param><key>id</key><value>lilacsat_vitfilt27_fb_0</value></param>
</block>
<block>
<key>lilacsat_vitfilt27_fb</key>
<param><key>id</key><value>lilacsat_vitfilt27_fb_0_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>lilacsat_vitfilt27_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>lilacsat_vitfilt27_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_0</source_block_id><sink_block_id>lilacsat_fec_decode_b_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_0_0</source_block_id><sink_block_id>lilacsat_fec_decode_b_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>csp_print_header_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>lilacsat_image_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>lilacsat_telemetry_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_fec_decode_b_0_0</source_block_id><sink_block_id>lilacsat_kiss_decode_pdu_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_fec_decode_b_0_0_0</source_block_id><sink_block_id>lilacsat_kiss_decode_pdu_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_kiss_decode_pdu_0</source_block_id><sink_block_id>csp_swap_header_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_vitfilt27_fb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lilacsat_vitfilt27_fb_0_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>demod_by70_1</value></param>
<param><key>title</key><value>Demod BY70-1</value></param>
<param><key>author</key><value>WEI Mingchuan, BG2BHC</value></param>
<param><key>description</key><value>BY70-1 telemetry and FM voice demodulator. Tested on GRC 3.7.8.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>digigain</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>equalizer_gain</value></param>
<param><key>label</key><value>Equalizer: Gain</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab@1:3,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fll_bw</value></param>
<param><key>label</key><value>FLL: Bandwidth</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab@1:0,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>1.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab@1:2,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>label</key><value>Time: Bandwidth</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tab@1:1,0</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>variable_constellation_0</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
<param><key>const_points</key><value>[-1, 1]</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>10**(digigain/20)</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>20</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>alpha</key><value>0.0001</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>7200</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>rolloff</key><value>alpha</value></param>
<param><key>filter_size</key><value>100</value></param>
<param><key>w</key><value>fll_bw</value></param>
</block>
<block>
<key>digital_lms_dd_equalizer_cc</key>
<param><key>id</key><value>digital_lms_dd_equalizer_cc_0_0</value></param>
<param><key>mu</key><value>equalizer_gain</value></param>
<param><key>num_taps</key><value>2</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>cnst</key><value>variable_constellation_0</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>loop_bw</key><value>timing_loop_bw</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>max_dev</key><value>0.05</value></param>
<param><key>osps</key><value>2</value></param>
</block>
<block>
<key>lilacsat_fec_decode_b</key>
<param><key>id</key><value>lilacsat_fec_decode_b_0_0</value></param>
<param><key>frame_len</key><value>114</value></param>
<param><key>using_m</key><value>True</value></param>
<param><key>using_convolutional_code</key><value>False</value></param>
<param><key>pass_all</key><value>False</value></param>
</block>
<block>
<key>lilacsat_fec_decode_b</key>
<param><key>id</key><value>lilacsat_fec_decode_b_0_0_0</value></param>
<param><key>frame_len</key><value>114</value></param>
<param><key>using_m</key><value>True</value></param>
<param><key>using_convolutional_code</key><value>False</value></param>
<param><key>pass_all</key><value>False</value></param>
</block>
<block>
<key>lilacsat_vitfilt27_fb</key>
<param><key>id</key><value>lilacsat_vitfilt27_fb_0</value></param>
</block>
<block>
<key>lilacsat_vitfilt27_fb</key>
<param><key>id</key><value>lilacsat_vitfilt27_fb_0_0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>10e3</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_3_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>48e3</value></param>
<param><key>cutoff_freq</key><value>8e3</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>48e3</value></param>
<param><key>ymin</key><value>-100</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label2</key><value></value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>name</key><value></value></param>
<param><key>type</key><value>float</value></param>
<param><key>avg</key><value>0.001</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label1</key><value>RSSI</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>Loop</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>quad_rate</key><value>48000</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>3.5e3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
</block>
<block>
<key>lilacsat_kiss_decode_pdu</key>
<param><key>id</key><value>lilacsat_kiss_decode_pdu_0</value></param>
</block>
<block>
<key>csp_swap_header</key>
<param><key>id</key><value>csp_swap_header_0</value></param>
</block>
<block>
<key>csp_print_header</key>
<param><key>id</key><value>csp_print_header_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>lilacsat_telemetry_parser</key>
<param><key>id</key><value>lilacsat_telemetry_parser_0</value></param>
</block>
<block>
<key>lilacsat_image_decoder</key>
<param><key>id</key><value>lilacsat_image_decoder_0</value></param>
<param><key>path</key><value>/tmp</value></param>
<param><key>display</key><value>True</value></param>
</block>
<block>
<key>lilacsat_plan13_cc</key>
<param><key>id</key><value>lilacsat_plan13_cc_0</value></param>
<param><key>enable</key><value>True</value></param>
<param><key>tle1</key><value>1 41909U 16083C   17002.67225097  .00392198  23238-5  79217-3 0  9993</value></param>
<param><key>tle2</key><value>2 41909  97.5869  80.5790 0213874 346.1470  13.3714 15.70100521   852</value></param>
<param><key>lon</key><value>126.6121</value></param>
<param><key>lat</key><value>45.7297</value></param>
<param><key>height</key><value>0</value></param>
<param><key>fc</key><value>436200000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>txrx</key><value>False</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>"TCP_CLIENT"</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>60069</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>type</key><value>"TCP_CLIENT"</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>60061</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>lilacsat_kiss_encode_pdu</key>
<param><key>id</key><value>lilacsat_kiss_encode_pdu_0</value></param>
<param><key>const_length</key><value>-1</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label1</key><value>A</value></param>
</block>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>lilacsat_vitfilt27_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>lilacsat_vitfilt27_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>lilacsat_plan13_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_0</source_block_id><sink_block_id>lilacsat_fec_decode_b_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_0_0</source_block_id><sink_block_id>lilacsat_fec_decode_b_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_lms_dd_equalizer_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lilacsat_fec_decode_b_0_0</source_block_id><sink_block_id>lilacsat_kiss_decode_pdu_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_fec_decode_b_0_0_0</source_block_id><sink_block_id>lilacsat_kiss_decode_pdu_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_kiss_decode_pdu_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>lilacsat_plan13_cc_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lilacsat_plan13_cc_0</source_block_id><sink_block_id>low_pass_filter_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lilacsat_vitfilt27_fb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lilacsat_vitfilt27_fb_0_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_rms_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_3_0_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lilacsat_kiss_encode_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>lilacsat_kiss_decode_pdu_0</source_block_id><sink_block_id>lilacsat_kiss_encode_pdu_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_kiss_decode_pdu_0</source_block_id><sink_block_id>csp_swap_header_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>csp_print_header_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>lilacsat_image_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>csp_swap_header_0</source_block_id><sink_block_id>lilacsat_telemetry_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_kiss_encode_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>

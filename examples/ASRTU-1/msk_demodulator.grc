options:
  parameters:
    generate_options: qt_gui
    id: asrtu1_msk_demodulator
    output_language: python
    title: ASRTU-1 MSK Demodulator
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: mf_arms
  id: variable
  parameters:
    value: '128'
  states: {}
- name: mf_pfb
  id: variable
  parameters:
    comment: Half-sine receive pulse
    value: np.sin(np.pi * np.arange(mf_arms * sps_recv // 2) / (mf_arms * sps_recv // 2))
  states: {}
- name: pulse_taps
  id: variable
  parameters:
    comment: Half-sine transmit pulse
    value: np.sin(np.pi * np.arange(sps_gen)/sps_gen)
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baudrate*8
  states: {}
- name: sps_gen
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sps_recv
  id: variable
  parameters:
    value: '16'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./ddt.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./recording_msk.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: np.exp(-1j*np.pi/4)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: np.exp(1j*np.pi/4)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[1, 3, 2, 0]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[3, 2, 0, 1]'
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[2, 0, 1,  3]'
  states: {}
- name: digital_map_bb_0_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[2, 0, 1,  3]'
  states: {}
- name: digital_map_bb_0_0_0_1
  id: digital_map_bb
  parameters:
    map: '[3, 2, 0, 1]'
  states: {}
- name: digital_map_bb_0_0_1
  id: digital_map_bb
  parameters:
    map: '[1, 3, 2, 0]'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.1'
    max_dev: '0.1'
    nfilters: mf_arms
    osps: '1'
    pfb_mf_taps: mf_pfb / np.sum(mf_pfb) * mf_arms
    resamp_type: digital.IR_PFB_MF
    sps: sps_recv//2
    ted_gain: '1.0'
    ted_type: digital.TED_DANDREA_AND_MENGALI_GEN_MSK
    type: cc
  states: {}
- name: dslwp_attach_sync_marker_0_0_0_0
  id: dslwp_attach_sync_marker
  parameters:
    check_length: 'True'
    data_format: '2'
    marker: '[0x1A, 0xCF, 0xFC, 0x1D]'
    msg_len: '1020'
    pass_other_length: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_0_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_0_1
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_0_1
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: lilacsat_sync_det_b_0_1
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'False'
    len: '1020'
    nrz: 'False'
    sync_word: '0x1acffc1d'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,0
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: baudrate * sps_recv /2
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: baudrate
    style1: '2'
    style2: '2'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: 1200e6+baudrate*2
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '20'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_imag_0, '0', blocks_float_to_complex_1, '1']
- [blocks_complex_to_imag_0_0, '0', blocks_float_to_complex_1_0, '1']
- [blocks_complex_to_real_0, '0', blocks_float_to_complex_1, '0']
- [blocks_complex_to_real_0_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_deinterleave_0, '0', blocks_complex_to_real_0, '0']
- [blocks_deinterleave_0, '1', blocks_complex_to_imag_0, '0']
- [blocks_deinterleave_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_deinterleave_0_0, '1', blocks_complex_to_imag_0_0, '0']
- [blocks_file_source_0, '0', analog_feedforward_agc_cc_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_1, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_const_sink_x_1, '0']
- [blocks_float_to_complex_1_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_float_to_complex_1_0, '0', qtgui_const_sink_x_1, '1']
- [blocks_multiply_const_xx_0, '0', blocks_deinterleave_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_deinterleave_0_0, '0']
- [blocks_multiply_xx_0, '0', analog_feedforward_agc_cc_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', lilacsat_sync_det_b_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', lilacsat_sync_det_b_0_1, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', lilacsat_sync_det_b_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0, '0', lilacsat_sync_det_b_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0_0, '0', lilacsat_sync_det_b_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0_0_0, '0', lilacsat_sync_det_b_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0_1, '0', lilacsat_sync_det_b_0_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_1_1, '0', lilacsat_sync_det_b_0_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_0_0_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_0_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_xx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_xx_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_1_0, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_1_0_0, '0']
- [digital_map_bb_0_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_1_0_0_0, '0']
- [digital_map_bb_0_0_0_1, '0', blocks_unpack_k_bits_bb_0_1_0_1, '0']
- [digital_map_bb_0_0_1, '0', blocks_unpack_k_bits_bb_0_1_1, '0']
- [digital_map_bb_0_1, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [dslwp_attach_sync_marker_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [lilacsat_sync_det_b_0, out, dslwp_attach_sync_marker_0_0_0_0, in]
- [lilacsat_sync_det_b_0_0, out, dslwp_attach_sync_marker_0_0_0_0, in]
- [lilacsat_sync_det_b_0_0_0, out, dslwp_attach_sync_marker_0_0_0_0, in]
- [lilacsat_sync_det_b_0_0_0_0, out, dslwp_attach_sync_marker_0_0_0_0, in]
- [lilacsat_sync_det_b_0_0_0_0_0, out, dslwp_attach_sync_marker_0_0_0_0, in]
- [lilacsat_sync_det_b_0_0_0_1, out, dslwp_attach_sync_marker_0_0_0_0, in]
- [lilacsat_sync_det_b_0_0_1, out, dslwp_attach_sync_marker_0_0_0_0, in]
- [lilacsat_sync_det_b_0_1, out, dslwp_attach_sync_marker_0_0_0_0, in]
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1

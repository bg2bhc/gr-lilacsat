options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: demod_asrtu1_audio
    output_language: python
    title: Demod ASRTU-1 Audio
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: alt
  id: variable
  parameters:
    value: '0'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: equalizer_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:3,0
    label: 'Equalizer: Gain'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.05'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fll_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:0,0
    label: 'FLL: Bandwidth'
    start: '0.0'
    step: '0.001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '-12e3'
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: lat
  id: variable
  parameters:
    value: '0'
  states: {}
- name: lon
  id: variable
  parameters:
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:2,0
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:1,0
    label: 'Time: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.05'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_0
    step_size: equalizer_gain
    type: lms
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: if_freq
    offset: '0'
    phase: '0'
    samp_rate: if_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:1,0
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '100'
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '2'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '0.05'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lilacsat_fec_decode_b_0_0
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '223'
    pass_all: 'True'
    using_convolutional_code: 'False'
    using_m: 'True'
  states: {}
- name: lilacsat_fec_decode_b_0_0_0
  id: lilacsat_fec_decode_b
  parameters:
    frame_len: '223'
    pass_all: 'True'
    using_convolutional_code: 'False'
    using_m: 'True'
  states: {}
- name: lilacsat_plan13_cc_0
  id: lilacsat_plan13_cc
  parameters:
    enable: 'False'
    fc: fc-if_freq
    height: alt
    lat: lat
    lon: lon
    samp_rate: if_rate
    tle1: tle_line1
    tle2: tle_line2
    txrx: 'False'
    verbose: 'False'
  states: {}
- name: lilacsat_vitfilt27_fb_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: lilacsat_vitfilt27_fb_0_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: if_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@0:1,0
    label1: A
    legend: 'False'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: if_rate
    fc: if_freq
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: 1,0
    legend: 'False'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: if_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0:2,0
    label2: ''
    legend: 'False'
    nconnections: '2'
    showports: 'True'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.001'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab@0:0,0
    label1: RSSI
    max: '-50'
    min: '-80'
    name: ''
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: if_rate
    fc: if_freq
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 0,0
    int_max: '0'
    int_min: '-100'
    showports: 'True'
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,2,1
    label0: Demodulator
    label1: Loop
    num_tabs: '2'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '1000'
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_real_0, '0', lilacsat_vitfilt27_fb_0, '0']
- [blocks_delay_0, '0', lilacsat_vitfilt27_fb_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', lilacsat_plan13_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', lilacsat_fec_decode_b_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', lilacsat_fec_decode_b_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_linear_equalizer_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0, '1']
- [digital_linear_equalizer_0, '0', blocks_complex_to_real_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0_0, '0']
- [lilacsat_fec_decode_b_0_0, out, blocks_message_debug_0_0, print_pdu]
- [lilacsat_fec_decode_b_0_0, out, zeromq_pub_msg_sink_0, in]
- [lilacsat_fec_decode_b_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [lilacsat_fec_decode_b_0_0_0, out, zeromq_pub_msg_sink_0, in]
- [lilacsat_plan13_cc_0, '0', low_pass_filter_0, '0']
- [lilacsat_vitfilt27_fb_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [lilacsat_vitfilt27_fb_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']
- [low_pass_filter_0, '0', analog_feedforward_agc_cc_0, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

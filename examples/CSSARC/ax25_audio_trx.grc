<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.make_dict(), pmt.init_u8vector(22, [0x3a, 0x42, 0x4a, 0x32, 0x54, 0x47, 0x2d, 0x30, 0x20, 0x20, 0x3a, 0x48, 0x65, 0x6c, 0x6c, 0x6f, 0x7b, 0x31, 0x32, 0x33, 0x34, 0x35]))</value></param>
<param><key>period</key><value>20000</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/lilac/msg2.wav</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>lilacsat_afsk1200_rx_f</key>
<param><key>id</key><value>lilacsat_afsk1200_rx_f_0</value></param>
</block>
<block>
<key>lilacsat_afsk1200_tx_f</key>
<param><key>id</key><value>lilacsat_afsk1200_tx_f_0</value></param>
<param><key>destination</key><value>APOCSS</value></param>
<param><key>maxoutbuf</key><value>4096</value></param>
<param><key>padding_zero</key><value>False</value></param>
<param><key>repeater1</key><value>WIDE1-2</value></param>
<param><key>repeater2</key><value>WIDE2-2</value></param>
<param><key>source</key><value>BG2BHC</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"RX"</value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>audio_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"TX"</value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>audio_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>lilacsat_afsk1200_rx_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>lilacsat_afsk1200_tx_f_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lilacsat_afsk1200_rx_f_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>lilacsat_afsk1200_tx_f_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lilacsat_afsk1200_tx_f_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
